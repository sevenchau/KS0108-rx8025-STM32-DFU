# IAR project HandReader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ; app; bsp; bsp\driver; bsp\phy; st_ucosii\uC-CPU\; st_ucosii\uC-CPU\ARM-Cortex-M3\IAR; st_ucosii\uC-DEV; st_ucosii\uC-LIB; st_ucosii\uC-LIB\Ports\ARM-Cortex-M3\IAR; st_ucosii\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; st_ucosii\uCOS-II\Source; stm32lib\library; stm32lib\startup; stm32lib\cmsis; stm32lib\library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HandReader.hex
  ILINK.IlinkOutputFile: stm32_.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    app/: app.c app_hooks.c main.c protocol.c queue.c rfdriver_reader.c rfdriver_reader.h serve.c
  group app/app_h
    app/: app.h app_cfg.h cpu_cfg.h includes.h os_cfg.h protocol.h queue.h serve.h stm32f10x.h stm32f10x_conf.h
  group app/lcd_windows
    app/: bmp.c lcdappshow.c lcdappshow.h window_includes.h windows1.c windows1.h windows2.c windows2.h windows3.c windows3.h
  group bsp
    bsp/: bsp.c bsp.h bsp_int.c bsp_periph.c
  group bsp/driver
    bsp/driver/: i2c_rx8025tdriver.c i2c_rx8025tdriver.h reboot.c reboot.h st_flashdriver.c st_flashdriver.h timerdriver.c timerdriver.h usartdriver.c usartdriver.h
  group bsp/driver/ks0108_lcd&key&ad
    bsp/driver/: ad_driver.c ad_driver.h font5x8.h graphic.c graphic.h keydriver.c keydriver.h KS0108-STM32.c KS0108.c KS0108.h
  group st_ucosii/uC-CPU
    st_ucosii/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    st_ucosii/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group st_ucosii/uC-DEV
    st_ucosii/uC-DEV/: device.c device.h
  group st_ucosii/uC-LIB
    st_ucosii/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    st_ucosii/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group st_ucosii/uCOS-II
    st_ucosii/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
    st_ucosii/uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group stm32lib/cmsis
    stm32lib/cmsis/: core_cm3.c core_cm3.h system_stm32f10x.c system_stm32f10x.h
  group stm32lib/library
    stm32lib/library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    stm32lib/library/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group stm32lib/startup
    stm32lib/startup/: app_vect_v5.c
